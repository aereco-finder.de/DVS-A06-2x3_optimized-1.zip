Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DVS-A06-2x3.IFC
Time: 2024-09-13T06:29:27
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DVS-A06-00200.90100.0223G (2)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.694; Bezeichnung: Vertikalblech; Bezeichnung2: DVV 05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0278B
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.5488728546607429; Bezeichnung: Ventilatortragblech; Bezeichnung2: Schrägdachsockel DVV0; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0334F
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,25; Weight: 2.263; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0335F
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 2.827; Bezeichnung: Sickenposition A 06/10; ProjectNumber: 11209; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0336F
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 2.817; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0338C (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.620; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.0340B (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.610; Bezeichnung2: Schalldämmkulisse VDR.FDSL / SDSL.DVV0; Bezeichnung: Rahmen; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.1371A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.022; Bezeichnung: Verschlusswinkel; Bezeichnung2: Durchgangsloch ø 4.9 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.1397A
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.033; Bezeichnung: Verschlusswinkel; Bezeichnung2: Sechskantloch SW9; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2039B
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.103; Bezeichnung: Abdeck- und Griffschutzblech; Bezeichnung2: mit Schalterschutz; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2048D
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.689; Bezeichnung: Vertikalblech DVV05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2689A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.680; Bezeichnung: Vertikalblech DVV05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2700A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,25; Weight: 1.413; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV06/ DVA10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2725A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: 1; Weight: 0.094; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.90100.2762A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.084; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.95000.0087A_Typenschild DV-A06
In: Default Storey
Material: XAC 33
SolidWorks Custom Properties - Material: XAC 33; Dicke: "Dicke@Blech1"; Weight: 0.08; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.95400.0001A_Warnhinweis
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 2.44; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00200.95400.0014A (2)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: 0,20; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-00700.95400.0012A (2)
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A06-00700.95400.0012A | Material: Hochdichte PE-Folie
DVS-A06-00700.95400.0012A

# IfcBuildingElementProxy: DVS-A06-10120.00110.0133A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Hauptwarengruppe: Konstruktion; Unterwarengruppe: Dämmstoffzuschnitte; Länge: 500; Breite: 210; Höhe: -; Material: RAF-SE (50); Dicke: 50; Weight: 0.184; Bezeichnung: Dämmung; Bezeichnung2: Schalldämmkulisse VDR.FDSL / SDSL.DVV0; Zuschnittlänge: 500; Zuschnittbreite: 210; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.00100.0087A_2_DV A05-10
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.012; Bezeichnung: Erdungsband 4mm²; Bezeichnung2: Lochmittenabstand 90mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.00200.0009A
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.008; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.00200.0010A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.008; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0026A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.001; Bezeichnung: Verschlussstopfen VST M20; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0040A_1_Default
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.016; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0040A_2_Default
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.012; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0040A_3
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0040A_4
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.001; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0051A
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0054A
In: Default Storey
Material: PE niedrige/mittlere Dichte
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: PE niedrige/mittlere Dichte; Dicke: "Dicke@Blech"; Weight: 0.003; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.08000.0059A (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.620 PA7001; Part Number: 50.620 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10200.09000.0030A (4)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Beschreibung: Sicherungsscheibe; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00030.0018A_Default
In: Default Storey
SolidWorks Custom Properties - DESIGN: KS Klemmscheibe für Wellen ohne Nut; REFERENCE: KS 5; SUPPLIER: SEEGER-ORBIS; TYPE: CATPART; Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Klemmscheibe M6; Bezeichnung2: DIN 99107-6; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00030.0025A
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: Stahl; OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00030.0032A (2)
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: 1.0226 (DX51D); OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A06-10400.00030.0032A | Material: 1.0226 (DX51D)
DVS-A06-10400.00030.0032A

# IfcBuildingElementProxy: DVS-A06-10400.00040.0002A_M8
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00040.0018A (2)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A06-10400.00040.0018A | Material: Stahl
DVS-A06-10400.00040.0018A

# IfcBuildingElementProxy: DVS-A06-10400.00050.0002A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00050.0003A_10400.00050.0003A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.006; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00050.0007A
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - IsToolboxPart: No; IsFastener: Yes; Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0015A_M5 x 10
In: Default Storey
Material: Verzinkter Stahl
SolidWorks Custom Properties - Description: Linsenschraube DIN 7985 M5 x 10 - A2K; Material: Verzinkter Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0030A_M6 x 20
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.007; Bezeichnung: Linsenschraube DIN 7985; Bezeichnung2: M6 x 20 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0127A
In: Default Storey
Material: 1.4301 (X5CrNi18-10)
SolidWorks Custom Properties - Material: 1.4301 (X5CrNi18-10); Dicke: -; Weight: 0.006; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0161A_M3 x 6 (2)
In: Default Storey
Material: Verzinkter Stahl
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Linsenschraube DIN 7985; Bezeichnung2: ISO 7045 - M3 x 6 - Z --- 6C; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0172A
In: Default Storey
SolidWorks Custom Properties - NN: DIN 913 (ISO 4026) - A2; NT: Hexagon socket set screws with flat point; NB: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; NBSYN: WUERTH $ARTNR. headless screw DIN 913 $NENN. $GUETE. $OBERFLAECHE.; LINA: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; ROWDESC: M8x40; ARTNR: 02618 40; MATERIAL: Stahl; GUETE: VORDEF; OBERFLAECHE: BLK; D: 8.000; D3: 6.466; P: 1.250; L: 40.000; DP: 5.500; S: 4.000; T: 5.000; SUPPLIER: WUERTH; ARTICLENO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; BOMINFO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.015; Bezeichnung: Gewindestift ISO 4026; Bezeichnung2: M8 x 40 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0173A_Default (2)
In: Default Storey
SolidWorks Custom Properties - A: 2.400; ARTICLENO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; ARTNR: 00465 12; B: 9.600; BOMINFO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; CREATOR: CADENAS GmbH; D: 5.000; D3: 4.019; DK: 10.000; GUETE: 4.8; K: 3.800; L: 12.000; LINA: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; M: 5.300; MATERIAL: ST; NB: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; NBSYN: WUERTH $ARTNR. oval-head screw DIN 7985 $NENN. $GUETE. $OBERFLAECHE.; NN: DIN 7985 (ISO 7045) - 4.8 - zinc-plated (A2K), blue passivated; NT: Cross recessed raised cheese head screws; OBERFLAECHE: A2K; P: 0.800; R: 0.400; RF: 10.000; ROWDESC: M5x12; SUPPLIER: WUERTH; X: 2.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A06-10400.00055.0173A_Default | Material: Stahl
DVS-A06-10400.00055.0173A_Default

# IfcBuildingElementProxy: DVS-A06-10400.00055.0182A (4)
In: Default Storey
Material: Edelstahl A2 / C1
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.003; Beschreibung: Dünnschaftschraube M5; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00055.0183A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0002A (113)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.001; Bezeichnung: Blindniet 3,0 x 6,0; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
36 x DVS-A06-10400.00100.0002A | Material: Stahl verzinkt/Stahl verzinkt, blau passiviert
77 x DVS-A06-10400.00100.0002A

# IfcBuildingElementProxy: DVS-A06-10400.00100.0003A (5)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Blindniete 4.0 x 8.0 mm; Bezeichnung2: Klemmbereich: 2.5-4.5 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0021A (2)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0022A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0029A (2)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVS-A06-10400.00100.0029A | Material: Verzinkter Stahl
DVS-A06-10400.00100.0029A

# IfcBuildingElementProxy: DVS-A06-10400.00100.0041A (2)
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0043A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.011; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0052A
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.00100.0058A (4)
In: Default Storey
Material: Edelstahl A2 / C1
SolidWorks Custom Properties - Description: RIVKLE® Einnietmutter M5; Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10400.01000.0002A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Perspex (TM) GS Acrylic Cast Sheet; Dicke: -; Weight: 0.001; Bezeichnung: Sicherungsstopfen; Bezeichnung2: Bohrungen d=8 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVS-A06-10500.00100.0005A_Ventilatortragblech A5-10
In: Default Storey
SolidWorks Custom Properties - Material: Gummi; Dicke: "Dicke@Blech1"; Weight: 0.015; Bezeichnung: Abdichtband; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcElementAssembly: DVS-A06-00200.90100.0339C
In: Default Storey
SolidWorks Custom Properties - Weight: 0.610; Bezeichnung: Schalldämmkulisse; Bezeichnung2: VDR.FDSL / SDSL.DVV0; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A06-02020.20420.0015C_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Bezeichnung2: Flachdachsockel mit Klappvorrichtung; Bezeichnung: Aereco DSF-A06/ A10 / 530664; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A06-10200.00100.0099B
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 13.09.2024; LastSaveName: wehnes; Material: -; Dicke: -; Weight: 0.038; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A06-10200.08000.0040A
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVS-A06-2x3
In: Default Storey
SolidWorks Custom Properties - Bezeichnung: DV - A06; Weight: 14.580; Material: -; Surface: -; ProjectNumber: 10149; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 01.10.2021; Dateityp: Baugruppe; Status: In Arbeit
